# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (6140000::V6.14::ARMCLANG)
  device: STM32L496ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: TencentOS_tiny +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L496xx,NUCLEO_STM32L496ZG,MBEDTLS_CONFIG_FILE=<qcloud/tls_psk_config.h>
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\..\..\examples\hello_world;..\..\TOS_CONFIG;..\..\..\..\kernel\hal\include;..\..\BSP\Hardware\Inc;..\..\..\..\components\ai\tflite_micro\ARM_CortexM4_lib;..\..\..\..\components\ai\tflite_micro\ARM_CortexM4_lib\third_party\flatbuffers\include;..\..\..\..\components\ai\tflite_micro\ARM_CortexM4_lib\third_party\gemmlowp;..\..\..\..\components\ai\tflite_micro\ARM_CortexM4_lib\third_party\kissfft;..\..\..\..\components\ai\tflite_micro\ARM_CortexM4_lib\third_party\ruy;..\..\..\..\components\ai\tflite_micro\ARM_CortexM4_lib\tensorflow\lite\micro\tools\make\downloads;..\..\..\..\devices\esp8266;..\..\..\..\net\at\include;..\..\..\..\components\security\mbedtls\3rdparty\include;..\..\..\..\components\security\mbedtls\wrapper\include;..\..\..\..\components\security\mbedtls\wrapper\include\qcloud;..\..\..\..\components\connectivity\qcloud-iot-explorer-sdk\3rdparty\include;..\..\..\..\components\connectivity\qcloud-iot-explorer-sdk\3rdparty\sdk_src\internal_inc;..\..\..\..\components\connectivity\qcloud-iot-explorer-sdk\3rdparty\include\exports;..\..\..\..\net\sal_module_wrapper;..\..\..\..\components\security\mbedtls\wrapper\include\qcloud;..\..\..\..\components\connectivity\qcloud-iot-explorer-sdk\3rdparty\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/User
    ../../BSP/Src/: main.c gpio.c stm32l4xx_hal_msp.c sys.c usart.c mcu_init.c dcmi.c dma.c stm32l4xx_it.c i2c.c spi.c tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32l4xx.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_stopwatch.c
  group tos/cmsis_os
    ../../../../osal/cmsis_os/: cmsis_os.c
  group hal
    ../../BSP/Hardware/Src/: delay.c lcd_2inch4.c lcd_config.c ov2640.c sccb.c
    ../../../../platform/hal/st/stm32l4xx/src/: tos_hal_uart.c
  group examples
    ../../../../examples/tflitemicro_person_detection/: tflitemicro_person_detection.c
    ./qcloud_user_code/: data_template_sample.c action_config.c events_config.c
  group tensorflow
    ./tflu_person_detection/: person_detect_model_data.cc model_settings.cc main_functions.cc image_provider.cc detection_responder.cc
    ../../../../components/ai/tflite_micro/KEIL/: retarget.c
    ../../../../components/ai/tflite_micro/ARM_CortexM4_lib/: tensorflow_lite_micro_M4.lib
  group module_wrapper
    ../../../../net/sal_module_wrapper/: sal_module_wrapper.c
    ../../../../net/tencent_firmware_module_wrapper/: tencent_firmware_module_wrapper.c
  group devices
    ../../../../devices/esp8266/: esp8266.c
  group at-framwork
    ../../../../net/at/src/: tos_at.c
  group mbedtls
    ../../../../components/security/mbedtls/3rdparty/src/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../../components/security/mbedtls/wrapper/src/: entropy_hardware_alt.c net_module_alt.c timing_alt.c
  group qcloud/port
    ../../../../components/connectivity/qcloud-iot-explorer-sdk/port/TencentOS_tiny/: HAL_AT_UART_tencentos_tiny.c HAL_Device_tencentos_tiny.c HAL_OS_tencentos_tiny.c HAL_TCP_module.c HAL_Timer_tencentos_tiny.c HAL_UDP_module.c
  group qcloud/protocol/mqtt
    ../../../../components/connectivity/qcloud-iot-explorer-sdk/3rdparty/sdk_src/protocol/mqtt/: mqtt_client.c mqtt_client_common.c mqtt_client_connect.c mqtt_client_net.c mqtt_client_publish.c mqtt_client_subscribe.c mqtt_client_unsubscribe.c mqtt_client_yield.c
  group qcloud/services/data_template
    ../../../../components/connectivity/qcloud-iot-explorer-sdk/3rdparty/sdk_src/services/data_template/: data_template_aciton.c data_template_client.c data_template_client_common.c data_template_client_json.c data_template_client_manager.c data_template_event.c
  group qcloud/utils
    ../../../../components/connectivity/qcloud-iot-explorer-sdk/3rdparty/sdk_src/utils/: json_parser.c json_token.c qcloud_iot_ca.c qcloud_iot_device.c qcloud_iot_log.c string_utils.c utils_aes.c utils_base64.c utils_getopt.c utils_hmac.c utils_list.c utils_md5.c utils_ringbuff.c utils_sha1.c utils_timer.c
  group qcloud/network
    ../../../../components/connectivity/qcloud-iot-explorer-sdk/3rdparty/sdk_src/network/: network_interface.c
    ../../../../components/connectivity/qcloud-iot-explorer-sdk/3rdparty/sdk_src/network/socket/: network_socket.c
    ../../../../components/connectivity/qcloud-iot-explorer-sdk/3rdparty/sdk_src/network/tls/: network_tls.c
    ../../../../components/connectivity/qcloud-iot-explorer-sdk/3rdparty/platform/tls/mbedtls/: HAL_DTLS_mbedtls.c HAL_TLS_mbedtls.c
software components: CMSIS:CORE 5.4.0
