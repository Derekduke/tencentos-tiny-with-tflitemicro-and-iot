# Keil uVision project STM32F746NGH6.uvprojx, settings and files
target STM32F746NGH6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F746NGH6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_HAL_DRIVER,STM32F746xx
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F7xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F7xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m7\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG;..\..\..\..\components\gui\LittlevGL\3rdparty\lvgl\src\lv_core;..\..\..\..\components\gui\LittlevGL\3rdparty\lvgl\src\lv_draw;..\..\..\..\components\gui\LittlevGL\3rdparty\lvgl\src\lv_font;..\..\..\..\components\gui\LittlevGL\3rdparty\lvgl\src\lv_hal;..\..\..\..\components\gui\LittlevGL\3rdparty\lvgl\src\lv_misc;..\..\..\..\components\gui\LittlevGL\3rdparty\lvgl\src\lv_objx;..\..\..\..\components\gui\LittlevGL\3rdparty\lvgl\src\lv_themes;..\..\..\..\components\gui\LittlevGL\3rdparty\lvgl;..\..\..\..\components\gui\LittlevGL\3rdparty\lvgl\src;..\..\..\..\components\gui\LittlevGL\3rdparty;..\..\..\..\components\gui\LittlevGL\3rdparty\lv_examples;..\..\..\..\components\gui\LittlevGL\3rdparty\lv_examples\lv_apps\demo;..\..\..\..\components\gui\LittlevGL\3rdparty\lv_examples\lv_tests\lv_test_theme;..\..\BSP\Utilities\STM32746G-Discovery;..\..\BSP\hal_stm_lvgl\tft;..\..\BSP\hal_stm_lvgl\touchpad;..\..\BSP\Utilities\Components\ft5336;..\..\..\..\components\gui\LittlevGL\3rdparty\lv_examples\lv_apps\benchmark;..\..\..\..\components\gui\LittlevGL\3rdparty\lv_examples\lv_apps\sysmon;..\..\..\..\components\gui\LittlevGL\3rdparty\lv_examples\lv_apps\terminal;..\..\..\..\components\gui\LittlevGL\3rdparty\lv_examples\lv_apps\tpcal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c mcu_init.c stm32f7xx_hal_msp.c usart.c stm32f7xx_it_lvgl.c
  group examples
    ../../../../examples/lvgl_gui_demo/: lvgl_demo.c
  group stm32f746-discovery
    ../../BSP/Utilities/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
    ../../BSP/Utilities/Components/ft5336/: ft5336.c
  group hal_stm_lvgl
    ../../BSP/hal_stm_lvgl/tft/: tft.c
    ../../BSP/hal_stm_lvgl/touchpad/: touchpad.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_ll_fmc.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32f7xx.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m7/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group lvgl/core
    ../../../../components/gui/LittlevGL/3rdparty/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group lvgl/draw
    ../../../../components/gui/LittlevGL/3rdparty/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
  group lvgl/fonts
    ../../../../components/gui/LittlevGL/3rdparty/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
  group lvgl/hal
    ../../../../components/gui/LittlevGL/3rdparty/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/misc
    ../../../../components/gui/LittlevGL/3rdparty/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
  group lvgl/objx
    ../../../../components/gui/LittlevGL/3rdparty/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
  group lvgl/themes
    ../../../../components/gui/LittlevGL/3rdparty/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lvgl/examples
    ../../../../components/gui/LittlevGL/3rdparty/lv_examples/lv_apps/benchmark/: benchmark.c benchmark_bg.c
    ../../../../components/gui/LittlevGL/3rdparty/lv_examples/lv_apps/demo/: demo.c img_bubble_pattern.c
    ../../../../components/gui/LittlevGL/3rdparty/lv_examples/lv_apps/sysmon/: sysmon.c
    ../../../../components/gui/LittlevGL/3rdparty/lv_examples/lv_apps/terminal/: terminal.c
    ../../../../components/gui/LittlevGL/3rdparty/lv_examples/lv_apps/tpcal/: tpcal.c
    ../../../../components/gui/LittlevGL/3rdparty/lv_examples/lv_tests/lv_test_theme/: lv_test_theme_1.c lv_test_theme_2.c
software components: CMSIS:CORE 4.3.0
