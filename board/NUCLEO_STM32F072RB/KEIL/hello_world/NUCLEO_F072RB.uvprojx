# Keil uVision project NUCLEO_F072RB.uvprojx, settings and files
target NUCLEO_F072RB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: NUCLEO_F072RB +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB,USE_HAL_DRIVER,STM32F072xB
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F0xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F0xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\arch\arm\arm-v6m\common\include;..\..\..\..\arch\arm\arm-v6m\cortex-m0\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c stm32f0xx_hal_msp.c stm32f0xx_it.c usart.c mcu_init.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32f0xx.c
  group tos/arch
    ../../../../arch/arm/arm-v6m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v6m/cortex-m0/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group examples
    ../../../../examples/hello_world/: hello_world.c
software components: CMSIS:CORE 4.3.0
