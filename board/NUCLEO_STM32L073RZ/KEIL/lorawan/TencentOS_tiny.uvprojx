# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: TencentOS_tiny +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx,USE_HAL_DRIVER,STM32L073xx
  c include: ..\..\BSP\Inc;../../../../platform/vendor_bsp/st/STM32L0xx_HAL_Driver/Inc;../../../../platform/vendor_bsp/st/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../platform/vendor_bsp/st/CMSIS/Device/ST/STM32L0xx/Include;../../../../platform/vendor_bsp/st/CMSIS/Include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m0+\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\kernel\hal\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG;..\..\..\..\devices\rhf76_lora;..\..\..\..\net\at\include;..\..\..\..\net\lora_module_wrapper;..\..\BSP\HardWare\HTS221;..\..\..\..\examples\LoRaWAN;..\..\BSP\HardWare\Common;..\..\BSP\HardWare\LIS3MDL;..\..\BSP\HardWare\LPS22HB;..\..\BSP\HardWare\LSM6DS3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c stm32l0xx_hal_msp.c usart.c mcu_init.c stm32l0xx_it_lorawan.c i2c.c
    ../../BSP/HardWare/HTS221/: HTS221.c
    ../../BSP/HardWare/Common/: bsp.c
    ../../BSP/HardWare/LIS3MDL/: LIS3MDL.c
    ../../BSP/HardWare/LPS22HB/: LPS22HB.c
    ../../BSP/HardWare/LSM6DS3/: LSM6DS3.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_flash_ex2.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32l0xx.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m0+/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_stopwatch.c
  group tos/cmsis_os
    ../../../../osal/cmsis_os/: cmsis_os.c
  group examples
    ../../BSP/Src/: lora_demo.c
  group devices
    ../../../../devices/rhf76_lora/: RHF76.c
  group hal
    ../../../../platform/hal/st/stm32l0xx/src/: tos_hal_uart.c
  group at
    ../../../../net/at/src/: tos_at.c
    ../../../../net/lora_module_wrapper/: lora_module_wrapper.c
software components: CMSIS:CORE 4.3.0
