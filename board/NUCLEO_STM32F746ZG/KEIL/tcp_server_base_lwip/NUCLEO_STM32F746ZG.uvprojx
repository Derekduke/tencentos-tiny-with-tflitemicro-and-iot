# Keil uVision project NUCLEO_STM32F746ZG.uvprojx, settings and files
target NUCLEO_STM32F746ZG (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: NUCLEO_STM32F746ZG +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_HAL_DRIVER,STM32F746xx
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F7xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F7xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m7\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG;..\..\..\..\net\lwip\3rdparty\src\include;..\..\..\..\net\lwip\port\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c mcu_init.c stm32f7xx_hal_msp.c stm32f7xx_it.c usart.c usb_otg.c bsp_eth.c lwip.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_exti.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_ll_usb.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32f7xx.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m7/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group lwip
    ../../../../net/lwip/3rdparty/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../net/lwip/3rdparty/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../net/lwip/3rdparty/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../net/lwip/3rdparty/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group lwip/port
    ../../../../net/lwip/port/src/: ethernetif.c sys_arch.c
  group lwip/config
    ../../TOS_CONFIG/: lwipopts.h
  group example
    ../../../../examples/tcp_udp_base_lwip/tcp_server/: tcp_server.c
software components: CMSIS:CORE 4.3.0
