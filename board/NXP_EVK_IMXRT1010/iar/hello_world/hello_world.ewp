# IAR project hello_world.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1011xxx5A NXP MIMXRT1011xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1011DAE5A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ..; ../../..; ..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011\CMSIS\Include; ..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011\drivers; ..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011\utilities\str; ..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011\utilities\debug_console; ..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011\components\uart; ..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011\components\serial_manager; ..\..\BSP\Inc; ..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011; ..\..\..\..\kernel\core\include; ..\..\..\..\arch\arm\arm-v7m\common\include; ..\..\..\..\arch\arm\arm-v7m\cortex-m7\iccarm; ..\..\..\..\osal\cmsis_os; ..\..\TOS_CONFIG; ..\..\..\..\kernel\pm\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1011DAE5A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_flexspi_nor.icf
configuration ram_0x1400_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_ram_0x1400.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1011DAE5A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1011DAE5A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_flexspi_nor.icf
configuration ram_0x1400_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_ram_0x1400.icf
  group CMSIS
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/serial_manager
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/uart
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/components/uart/: lpuart_adapter.c uart.h
  group device
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/: fsl_device_registers.h MIMXRT1011.h MIMXRT1011_features.h system_MIMXRT1011.c system_MIMXRT1011.h
  group drivers
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h
  group startup
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/iar/: startup_MIMXRT1011.s
  group tos/arch
    ../../../../arch/arm/arm-v7m/cortex-m7/iccarm/: port.h port_c.c port_config.h port_s.S
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/common/include/: tos_cpu.h tos_cpu_def.h tos_cpu_types.h
  group tos/cmsis_os
    ../../../../osal/cmsis_os/: cmsis_os.c cmsis_os.h
  group tos/kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
    ../../../../kernel/core/include/: tos_binary_heap.h tos_char_fifo.h tos_compiler.h tos_completion.h tos_config_check.h tos_config_default.h tos_countdownlatch.h tos_err.h tos_event.h tos_global.h tos_k.h tos_klib.h tos_ktypes.h tos_list.h tos_mail_queue.h tos_message_queue.h tos_mmblk.h tos_mmheap.h tos_mutex.h tos_pend.h tos_priority_mail_queue.h tos_priority_message_queue.h tos_priority_queue.h tos_ring_queue.h tos_robin.h tos_sched.h tos_sem.h tos_slist.h tos_sys.h tos_task.h tos_tick.h tos_time.h tos_timer.h
  group user
    ../../bsp/Src/: board.c clock_config.c hello_world.c pin_mux.c
  group utilities
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/utilities/: fsl_assert.c
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../bsp/xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
