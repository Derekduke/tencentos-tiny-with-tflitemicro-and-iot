# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: TencentOS_tiny +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,
  c include: ..\..\..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Legacy;..\..\..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\..\..\kernel\core\include;..\TOS-CONFIG;..\..\..\..\..\..\platform\arch\arm\cortex-m4\keil;..\..\..\..\..\..\kernel\pm\include;..\..\..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\..\..\..\..\components\ota\recovery\include;..\..\..\..\..\..\components\ota\common\crc;..\..\..\..\..\..\components\ota\common\image;..\..\..\..\..\..\components\ota\common\flash;..\..\..\..\..\..\components\ota\common\bsdiff;..\..\..\..\..\..\components\ota\common\lzma\3rdparty;..\..\..\..\..\..\components\ota\common\lzma\wrapper;..\..\..\..\..\..\components\ota\common\partition;..\..\..\..\..\..\components\ota\common\env;..\..\..\..\..\..\components\fs\kv\include;..\..\..\..\..\..\components\ota\common\info;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../platform/vendor_bsp/st/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Hardware
    ../../../../BSP/Hardware/ONCHIP_FLASH/: onchip_flash.c onchip_flash_ota.c
  group kernel
    ../../../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_barrier.c tos_bitmap.c tos_rwlock.c tos_stopwatch.c
  group cpu
    ../../../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_s.S port_c.c
    ../../../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group config
    ../TOS-CONFIG/: tos_config.h
  group ota_recovery
    ../../../../../../components/ota/recovery/: ota_recovery.c ota_recovery_xip.c ota_patch.c ota_patch_xip.c
  group ota_common
    ../../../../../../components/ota/common/flash/: ota_flash.c
    ../../../../../../components/ota/common/crc/: crc8.c
    ../../../../../../components/ota/common/image/: ota_image.c
    ../../../../../../components/ota/common/env/: ota_env.c
    ../../../../../../components/ota/common/partition/: ota_partition.c
    ../../../../../../components/ota/common/info/: ota_info.c
  group lzma
    ../../../../../../components/ota/common/lzma/3rdparty/: 7zAlloc.c 7zArcIn.c 7zBuf.c 7zBuf2.c 7zCrc.c 7zCrcOpt.c 7zDec.c 7zFile.c 7zStream.c Aes.c AesOpt.c Alloc.c Bcj2.c Bcj2Enc.c Bra.c Bra86.c BraIA64.c CpuArch.c Delta.c DllSecur.c LzFind.c Lzma2Dec.c Lzma2Enc.c Lzma86Dec.c Lzma86Enc.c LzmaDec.c LzmaEnc.c LzmaLib.c Ppmd7.c Ppmd7Dec.c Ppmd7Enc.c Sha256.c Sort.c Xz.c XzCrc64.c XzCrc64Opt.c XzDec.c XzEnc.c XzIn.c
  group lzma_wrapper
    ../../../../../../components/ota/common/lzma/wrapper/: lzma_uncompress.c
  group kv
    ../../../../../../components/fs/kv/: tos_kv.c
software components: CMSIS:CORE 4.3.0
