# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TencentOS_tiny
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF51
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\..\BSP\Inc;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m0+\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./: arm_startup_nrf51.s
  group User
    ../../BSP/Src/: main.c
  group Drivers
    ../../BSP/Src/: nrf_delay.c rtc.c simple_uart.c system_nrf51.c
  group tos/arch
    ../../../../arch/arm/arm-v6m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v6m/cortex-m0/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
software components: CMSIS:CORE 5.3.0
