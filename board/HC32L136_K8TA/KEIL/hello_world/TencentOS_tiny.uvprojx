# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TencentOS_tiny
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\hdsc\HC32L136_DDL_Rev1.0.0\mcu\common;..\..\..\..\platform\vendor_bsp\hdsc\HC32L136_DDL_Rev1.0.0\driver\inc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m0+\armcc;..\..\TOS-CONFIG;..\..\..\..\osal\cmsis_os;..\..\..\..\examples\helloworld
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group common
    ../../../../platform/vendor_bsp/hdsc/HC32L136_DDL_Rev1.0.0/mcu/common/: system_hc32l136.c
    ./: startup_hc32l136.s
  group source
    ../../BSP/Src/: led.c main.c usart.c
  group driver
    ../../../../platform/vendor_bsp/hdsc/HC32L136_DDL_Rev1.0.0/driver/src/: ddl.c interrupts_hc32l136.c sysctrl.c gpio.c lpuart.c uart.c flash.c
  group kernel
    ../../../../kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c
  group cpu
    ../../../../arch/arm/arm-v7m/cortex-m0+/armcc/: port_s.S port_c.c
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group config
    ../../TOS-CONFIG/: tos_config.h
  group cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group examples
    ../../../../examples/hello_world/: hello_world.c
software components: CMSIS:CORE 5.1.2
