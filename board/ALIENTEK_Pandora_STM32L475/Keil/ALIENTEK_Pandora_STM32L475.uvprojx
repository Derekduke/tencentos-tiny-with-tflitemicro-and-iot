# Keil uVision project ALIENTEK_Pandora_STM32L475.uvprojx, settings and files
target ALIENTEK_Pandora_STM32L475 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: TencentOS_tiny +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx,USE_HAL_DRIVER,STM32L475xx
  c include: ..\..\..\platform\vendor_bsp\st/STM32L4xx_HAL_Driver/Inc/Legacy;..\..\..\platform\vendor_bsp\st/CMSIS/Device/ST/STM32L4xx/Include;..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc;..\..\..\platform\vendor_bsp\st/CMSIS/Include;..\BSP\Inc;..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\..\kernel\core\include;..\..\..\osal\cmsis_os;..\..\..\examples\hello_world;..\..\..\arch\arm\arm-v7m\common\include;..\TOS-CONFIG;..\BSP\Hardware\LCD;..\..\..\kernel\hal\include;..\..\..\kernel\pm\include;..\BSP\Hardware\SPI3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/User
    ../BSP/Src/: main.c gpio.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c mcu_init.c spi.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../platform/vendor_bsp/st/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../BSP/Src/: system_stm32l4xx.c
  group tos/arch
    ../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
    ../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group tos/kernel
    ../../../kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c
  group example
    ../../../examples/hello_world/: hello_world.c
  group hardware
    ../BSP/Hardware/LCD/: lcd.c
  group tos/cmsis
    ../../../osal/cmsis_os/: cmsis_os.c
software components: CMSIS:CORE 5.2.0
