# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL27Z64VLH4 NXP
  pack: NXP.MKL27Z644_DFP.10.0.3
  cpu: CPUTYPE("Cortex-M0+")
  output: TencentOS-tiny
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MKL27Z64VLH4, FRDM_KL27Z, FREEDOM, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\nxp\\MKL27Z64VLH4\CMSIS;..\..\..\..\platform\vendor_bsp\nxp\MKL27Z64VLH4\drivers\Inc;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m0+\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS-CONFIG
  asm define: DEBUG
  asm include: board;source;CMSIS;board/src;doc;drivers;startup;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: MKL27Z64xxx4_flash.scf
  link misc: --remove
  group startup
    ./: startup_MKL27Z644.s
  group app
    ../../BSP/Src/: main.c
  group board/src
    ../../BSP/Src/: board.c clock_config.c fsl_assert.c fsl_debug_console.c fsl_io.c fsl_log.c fsl_str.c pin_mux.c
    ../../../../platform/vendor_bsp/nxp/MKL27Z64VLH4/CMSIS/: system_MKL27Z644.c
  group drivers
    ../../../../platform/vendor_bsp/nxp/MKL27Z64VLH4/drivers/Src/: fsl_clock.c fsl_common.c fsl_ftfx_cache.c fsl_ftfx_controller.c fsl_ftfx_flash.c fsl_ftfx_flexnvm.c fsl_gpio.c fsl_lpuart.c fsl_smc.c fsl_uart.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m0+/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
