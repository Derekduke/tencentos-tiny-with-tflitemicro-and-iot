# Keil uVision project NuvotonTos.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: M251KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: NuvotonTos
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: ..\..\..\platform\vendor_bsp\Nuvoton\Nuvoton_M251\StdDriver\inc;..\TOS_CONFIG;..\..\..\arch\arm\arm-v8m\common\include;..\..\..\arch\arm\arm-v8m\cortex-m23\armcc;..\..\..\kernel\core\include;..\..\..\kernel\pm\include;..\BSP\Src;..\BSP\Inc;..\..\..\platform\vendor_bsp\st\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../BSP/Src/: system_M251.c
    ./: startup_M251.s
  group StdDriver
    ../../../platform/vendor_bsp/Nuvoton/Nuvoton_M251/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group USER
    ../BSP/Src/: main.c
  group Tos/arch
    ../../../arch/arm/arm-v8m/common/: tos_cpu.c tos_fault.c
    ../../../arch/arm/arm-v8m/cortex-m23/armcc/: port_s.S port_c.c
  group Tos/kernel
    ../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group Tos/config
    ../TOS_CONFIG/: tos_config.h
software components: CMSIS:CORE 5.0.1
