# IAR project stm8_project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: ..\..\..\..\kernel\core\include; ..\..\..\..\arch\stm8\common\include; ..\..\..\..\arch\stm8\iccstm8; ..\..\BSP\include; ..\..\LIB\inc; ..\..\TOS-CONFIG; ..\..\USER; ..\..\USER; ..\..\..\..\components\shell\include; ..\..\..\..\kernel\hal\include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8_project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group arch
    ../../../../arch/stm8/iccstm8/: port.h port_c.c port_config.h port_s.S
    ../../../../arch/stm8/common/: tos_cpu.c tos_fault.c
  group bsp
    ../../BSP/src/: hal_uart.c rtc.c tim.c uart.c
  group example
    ../../../../examples/shell/: shell_sample.c
  group kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group lib/inc
    ../../LIB/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group lib/src
    ../../LIB/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group shell
    ../../../../components/shell/: tos_shell.c tos_shell_commands.c
  group TOS-CONFIG
    ../../TOS-CONFIG/: tos_config.h
  group user
    ../../USER/: main.c stm8l15x_it_shell.c
