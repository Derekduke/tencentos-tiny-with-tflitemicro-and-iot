# IAR project STM32F407VGT6_discovery.ewp, settings and files
configuration STM32F407VGT6_discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ..\..\BSP\Inc; ..\..\..\..\platform\vendor_bsp\st\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\platform\vendor_bsp\st\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\platform\vendor_bsp\st\CMSIS\Include; ..\..\..\..\arch\arm\arm-v7m\common\include; ..\..\..\..\arch\arm\arm-v7m\cortex-m4\iccarm; ..\..\..\..\kernel\core\include; ..\..\..\..\kernel\pm\include; ..\..\..\..\osal\cmsis_os; ..\..\TOS_CONFIG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F407VGT6_discovery.hex
  ILINK.IlinkOutputFile: STM32F407VGT6_discovery.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/examples
    ../../../../examples/hello_world/: hello_world.c
  group Application/User
    ../../BSP/Src/: gpio.c main.c mcu_init.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group TencentOS-tiny/arch
    ../../../../arch/arm/arm-v7m/cortex-m4/iccarm/: port_c.c port_s.S
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group TencentOS-tiny/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group TencentOS-tiny/kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
